File: Loom/New BSPD/Timers.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U6 4011

Commit message: Fix BSPD Crystal Footprint
Parts:
- gave numbers to parts that had none: 3
